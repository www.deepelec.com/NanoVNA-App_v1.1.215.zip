! NanoVNA-App
! Date: 2024-02-22 10:33:23
! Start: 2.2GHz Stop: 2.6GHz Points: 201
! S-Parameter data: F S11 S21 S12 S22
# Hz S RI R 50
!  Frequency  S11_Real  S11_Imag  S21_Real  S21_Imag  S12_Real  S12_Imag  S22_Real  S22_Imag
! Worked out from all points (weakly coupled two-port):
!   201 points, 2.2 GHz to 2.6 GHz, reference 50 ohm
!   highest |S21| = -28.38 dB at 2.496 GHz (marker M1); lowest = -52.9 dB at 2.508 GHz (marker M2)
!   lowest |S11| = -24.2 dB at 2.454 GHz (marker M3), VSWR 1.13, Z = 44.3 - j1.3 ohm
!   |S11| at or under -10 dB: 2.274 GHz to end of sweep
!   S12 and S22 are empty: the file has one direction only
!   S11 on the Smith chart (normalised r, x): 2.2 GHz: 0.39, +0.24; 2.242 GHz: 0.75, +0.69; 2.326 GHz: 1.46, +0.20; 2.6 GHz: 0.92, -0.38
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! magnitudes (dB):
! f  S11  S21
! 2.2 GHz  -6.6  -34.3
! 2.242 GHz  -8.2  -33.7
! 2.268 GHz  -9.7  -36.0
! 2.3 GHz  -12.0  -40.8
! 2.306 GHz  -12.5  -30.9
! 2.326 GHz  -13.8  -33.2
! 2.334 GHz  -13.8  -33.9
! 2.376 GHz  -13.3  -30.8
! 2.38 GHz  -13.0  -40.0
! 2.382 GHz  -13.2  -30.2
! 2.4 GHz  -14.2  -30.4
! 2.454 GHz  -24.2  -32.1
! 2.468 GHz  -22.8  -29.9
! 2.494 GHz  -17.4  -36.6
! 2.496 GHz  -16.8  -28.4
! 2.504 GHz  -15.5  -34.2
! 2.508 GHz  -15.3  -52.9
! 2.51 GHz  -14.7  -32.3
! 2.514 GHz  -14.4  -42.3
! 2.516 GHz  -14.3  -31.3
! 2.534 GHz  -13.5  -32.7
! 2.6 GHz  -14.0  -41.0
